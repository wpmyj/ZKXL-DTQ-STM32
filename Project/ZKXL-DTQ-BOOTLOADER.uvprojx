# Keil uVision project ZKXL-DTQ-BOOTLOADER.uvprojx, settings and files
target ZKXL-DTQ-BOOTLOADER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DTQ_RP551CPU_BOOTLOADER_V0100.hex +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,ZL_RP551_MAIN_F
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\include;..\User;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CmsisCore
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Stdlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Include
    ../include/: define.h init.h main.h stm32f10x_conf.h stm32f10x_it.h eeprom.h version.h gpio.h nrf.h whitelist.h board.h zl_rp551_main_e.h zl_rp551_main_f.h
  group Bsp
    ../Bsp/: nrf.c eeprom.c gpio.c baord.c
  group User
    ../User/: main.c app_handle_layer.c app_timer.c init.c stm32f10x_it.c version.c whitelist.c
