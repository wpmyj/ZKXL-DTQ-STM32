# Keil uVision project DTQ-STM32-ZKXL0200.uvprojx, settings and files
target v0.1.3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DTQ-STM32-ZKXL0200
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,ZL_RP551_MAIN_F
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\include;..\User;..\Bsp;..\Libraries\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Stdlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Include
    ../include/: board.h define.h eeprom.h gpio.h init.h m24sr_cmd.h main.h nrf.h ringbuffer.h stm32f10x_conf.h stm32f10x_it.h version.h whitelist.h zl_rp551_main_e.h zl_rp551_main_f.h
  group Bsp
    ../Bsp/: baord.c eeprom.c gpio.c m24sr_cmd.c mfrc500.c mfrc500_hw.c mfrc500_ios14443.c nrf.c
  group User
    ../User/: app_card_process.c app_handle_layer.c app_send_data_process.c app_serial_cmd_process.c app_show_message_process.c app_spi_send_data_process.c app_timer.c init.c main.c ringbuffer.c stm32f10x_it.c version.c whitelist.c
  group cJSON
    ../Libraries/cJSON/: cJSON.c cJSON_Utils.c
software components: CMSIS:CORE 4.3.0
