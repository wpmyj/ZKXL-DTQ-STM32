# Keil uVision project drl51822project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DTQ_HT43_WHTY0109_V0106 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_LOG_USES_RTT=1 BOARD_PCA10028 NRF_LOG_USES_UART=1 NRF51 SWI_DISABLE0 NRF51
  c misc: --c99
  c include: ..\components\drivers_nrf\hal;..\components\toolchain\CMSIS\Include;..\components\drivers_nrf\delay;..\components\properitary_rf\esb;..\components\drivers_nrf\nrf_soc_nosd;..\components\libraries\util;..\components\toolchain;..\components\libraries\timer;..\components\libraries\scheduler;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\gpiote;..\components\libraries\button;..\components\drivers_nrf\wdt;..\components\drivers_nrf\clock;..\components\drivers_nrf\adc;..\user;..\user\M24SR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../user/: main.c lcd.c rtc.c key.c radio.c adc.c define.c timer.c ringbuffer.c application.c uart.c power.c clock.c
    ../user/M24SR/: drv_I2C_M24SR.c drv_M24SR.c lib_M24SR.c lib_NDEF.c lib_TagType4.c
  group lib
    ../user/: simple_uart.c
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/properitary_rf/esb/: nrf_esb.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c app_util_platform.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/adc/: nrf_drv_adc.c
    ../components/drivers_nrf/hal/: nrf_adc.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
  group device
    ../components/toolchain/: system_nrf51.c
    ../components/toolchain/arm/: arm_startup_nrf51.s
  group include
    ../user/: iic.h simple_uart.h my_spi.h my_misc_fun.h
